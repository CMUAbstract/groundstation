<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>SpriteDecoder</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chip_rate</value></param>
<param><key>value</key><value>48e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>256000</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>256</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>infile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>infile</value></param>
<param><key>short_id</key><value>i</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>in.dat</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>prnid0</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>prnid1</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>sprite_correlator_cf</key>
<param><key>id</key><value>sprite_correlator_cf_0</value></param>
<param><key>prn_id0</key><value>prnid0</value></param>
<param><key>prn_id1</key><value>prnid1</value></param>
</block>
<block>
<key>sprite_peak_decimator_ff</key>
<param><key>id</key><value>sprite_peak_decimator_ff_0</value></param>
<param><key>window_size</key><value>512</value></param>
</block>
<block>
<key>sprite_peak_decimator_ff</key>
<param><key>id</key><value>sprite_peak_decimator_ff_0_0</value></param>
<param><key>window_size</key><value>512</value></param>
</block>
<block>
<key>sprite_soft_decoder_c</key>
<param><key>id</key><value>sprite_soft_decoder_c_0</value></param>
<param><key>threshold</key><value>.85</value></param>
</block>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>sprite_peak_decimator_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>sprite_soft_decoder_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>sprite_correlator_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sprite_correlator_cf_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sprite_correlator_cf_0</source_block_id><sink_block_id>sprite_peak_decimator_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sprite_peak_decimator_ff_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sprite_peak_decimator_ff_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
